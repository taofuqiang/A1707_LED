# Keil uVision project Project.uvprojx, settings and files
target STM3210E_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E_EVAL +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,USE_STM3210E_EVAL,Z_SOLO,STDC,ZLIB_CONST
  c misc: --C99
  c include: ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\common_lib;..\zlib-1.2.11;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/User
    ../Src/: main.c stm32f1xx_it.c drv_swo.c iap_if.c flash_if.c app_board.c ota_protocol.c stm32_uart.c drv_switch.c drv_watchdog.c stm32_gpio_irq.c usdl_buf.c stm32_Inrtc.c drv_can.c canbus_middle.c
  group Example/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_can.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_usart.c stm32f1xx_hal_pwr.c
  group commom_lib
    ../common_lib/: usdl_bit.c usdl_calc.c usdl_conversion.c usdl_data.c usdl_io.c usdl_list.c usdl_mem.c usdl_string.c usdl_time.c usdl_tools.c
  group zlib
    ../zlib-1.2.11/: compress.c uncompr.c deflate.c inflate.c inftrees.c zutil.c adler32.c crc32.c trees.c inffast.c
software components: CMSIS:CORE 5.0.2
